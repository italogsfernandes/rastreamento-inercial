# Keil uVision project Leitor_new_library.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24E1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: Leitor_new_library +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 read_minimum.c
