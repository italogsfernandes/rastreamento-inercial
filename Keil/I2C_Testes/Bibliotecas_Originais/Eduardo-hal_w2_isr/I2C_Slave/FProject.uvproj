# Keil uVision project FProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: FProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hal;..\hal\nrf24le1;..\common
  group Source Group 1
    ./: STARTUP.A51 main.c
  group HAL
    ../hal/: hal_delay.c
    ../hal/nrf24le1/: hal_w2.c
