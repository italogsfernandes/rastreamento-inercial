# Keil uVision project IICBUS.uvproj, settings and files
target APP (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: IICBUS +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 IICBUS_test.c
  group inc
    ./: IIC_app.c
