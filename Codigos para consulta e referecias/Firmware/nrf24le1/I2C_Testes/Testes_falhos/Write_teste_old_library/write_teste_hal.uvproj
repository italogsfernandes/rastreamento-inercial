# Keil uVision project write_teste_hal.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24E1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: write_teste_hal +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 write_teste_hal.c
