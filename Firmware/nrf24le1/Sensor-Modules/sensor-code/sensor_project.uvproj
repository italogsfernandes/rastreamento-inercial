# Keil uVision project sensor_project.uvproj, settings and files
target Sensor (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: sensor_project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\libraries;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24le1;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\c51
  group Application
    ./: sensor.c
  group HAL
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
    ../../libraries/: hal_w2_isr.c
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/nrf24le1/: hal_uart.c
